# Keil uVision project FATFS.uvprojx, settings and files
target FATFS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FATFS +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40 STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\MALLOC;..\USMART;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\FATFS\exfuns;..\FATFS\src;..\FWLIB\inc;..\HARDWARE\SD;..\HARDWARE\WS2812B;..\HARDWARE\Encoder;..\HARDWARE\ST7789;..\HARDWARE\DMA;..\HARDWARE\OLED;..\TEXT;..\HARDWARE\BEEPER;..\HARDWARE\Random;..\HARDWARE\Key;..\HARDWARE\DCMI;..\HARDWARE\OV2640;..\HARDWARE\EasyTracered
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/Key/: Key.h
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/WS2812B/: WS2812B.c WS2812B.h
    ../HARDWARE/Encoder/: Encoder.c Encoder.h
    ../HARDWARE/ST7789/: ST7789_Init.c ST7789_Init.h lcd.c lcd.h
    ../HARDWARE/DMA/: MyDMA.c MyDMA.h
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BEEPER/: BEEPER.c BEEPER.h
    ../HARDWARE/Random/: Random.c Random.h
    ../HARDWARE/DCMI/: dcmi.c dcmi.h
    ../HARDWARE/OV2640/: ov2640.c ov2640.h ov2640cfg.h sccb.c sccb.h
    ../HARDWARE/EasyTracered/: EasyTracered.c EasyTracered.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_i2c.c stm32f4xx_dcmi.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group README
    ../: readme.txt
  group TEXT
    ../TEXT/: fontupd.c text.c
